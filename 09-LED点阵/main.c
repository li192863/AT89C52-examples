#include <REGX52.H>
#include "Delay.h"
#include "LEDMatrix.h"


unsigned char code Animation[] = {
    0x3E,0x2A,0x3E,0x01,0x3D,0x56,0xDE,0x75,
    0x5D,0x03,0x00,0x10,0x29,0x2D,0xBA,0x6D,
    0x29,0x28,0x30,0x00,0x00,0x01,0x06,0x06,
    0x00,0x00,0x08,0x10,0x22,0x01,0xFF,0x00,
    0x20,0x10,0x08,0x00,0x00,0xFF,0x92,0x6C,
    0x01,0x5A,0x69,0xDF,0x48,0x4A,0x01,0x00,
    0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00
};

void main()
{
    unsigned char i, Offset = 0, Count = 0;
    void LEDMatrix_Init();
    while (1)
    {
        for (i = 0; i < 8; i++)
        {
            LEDMatrix_ShowColumn(i, Animation[(i + Offset) % 60]);
        }
        
        Count++;
        if (Count > 8)
        {
            Count = 0;
            Offset++;
        }
    }
}



